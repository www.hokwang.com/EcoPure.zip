Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: EcoPure.IFC
Time: 2026-07-29T06:08:32
Written by: SwIFC
Made in: SolidWorks 2023

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: EcoPure
In: Default Storey
PredefinedType: ELEMENT; Material: Steel
